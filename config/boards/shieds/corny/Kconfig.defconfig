## config/boards/shields/corny/Kconfig.shield
```kconfig
config SHIELD_CORNY
    bool "Corny 42-Key Split Keyboard"
    help
      Enable support for the Corny 42-key split keyboard.
```
